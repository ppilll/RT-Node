# Keil uVision project build_project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P3a_UNVERIFIED_NOT_FOR_FLASH
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: P1A_ACTUATOR_TEST_ENABLE=0,P1A_AUTOTEST_ENABLE=0,P1A_AUTOTEST_CASE=1,P1B_AUTOTEST_ENABLE=0,STM32F103xE,USE_HAL_DRIVER,P2B_OUTPUT_STAGE=0,P3A_CAN_TIMING_CONFIRMED=0,P3A_CAN_UNVERIFIED_BUILD_ONLY=1,P3A_CAN_BITRATE=500000UL,P3A_CAN_PRESCALER=4UL,P3A_CAN_BS1_TQ=14UL,P3A_CAN_BS2_TQ=3UL,P3A_CAN_SJW_TQ=1UL
  c include: ..\App\actuator\include;..\Core\Inc;..\Driver\CMSIS\Include;..\Driver\CMSIS\Device\ST\STM32F1xx\Include;..\Driver\STM32F1xx_HAL_Driver\Inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\App\imu\include;..\Driver\imu;..\App\can
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Core/Src/: main.c interrupts.c freertos_static.c rtos_hooks.c
  group Actuator
    ../App/actuator/src/: actuator.c
  group Startup
    ../Startup/: startup_stm32f103xe.s
  group CMSIS
    ../Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group HAL
    ../Driver/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_can.c stm32f1xx_hal_dma.c
  group tests
    ../App/p1a_test/: p1a_test.c
  group Control
    ../App/control/: control.c control_policy.c local_follow.c
    ../App/p1b_test/: p1b_test.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/: tasks.c list.c queue.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group CAN
    ../App/can/: can_app.c
  group IMU
    ../Driver/imu/: icm20602.c icm20602_data.c
    ../App/imu/src/: imu_fusion.c imu.c
