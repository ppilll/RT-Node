# Keil uVision project build_project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x0007F800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: P6b_PRODUCTION_STAGE0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: P1A_ACTUATOR_TEST_ENABLE=0,P1A_AUTOTEST_ENABLE=0,P1A_AUTOTEST_CASE=1,P1B_AUTOTEST_ENABLE=0,STM32F103xE,USE_HAL_DRIVER,BME280_64BIT_ENABLE,P3B_OUTPUT_STAGE=0,P6_WDG_TEST_ENABLE=0,P6_WDG_TEST_UNLOADED_ACK=0
  c include: F:\嵌入式Linux学习资料\RT-Node\App\actuator\include;F:\嵌入式Linux学习资料\RT-Node\Core\Inc;F:\嵌入式Linux学习资料\RT-Node\Driver\CMSIS\Include;F:\嵌入式Linux学习资料\RT-Node\Driver\CMSIS\Device\ST\STM32F1xx\Include;F:\嵌入式Linux学习资料\RT-Node\Driver\STM32F1xx_HAL_Driver\Inc;F:\嵌入式Linux学习资料\RT-Node\Middlewares\FreeRTOS\include;F:\嵌入式Linux学习资料\RT-Node\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;F:\嵌入式Linux学习资料\RT-Node\App\imu\include;F:\嵌入式Linux学习资料\RT-Node\Driver\imu;F:\嵌入式Linux学习资料\RT-Node\App\can;F:\嵌入式Linux学习资料\RT-Node\App\uart;F:\嵌入式Linux学习资料\RT-Node\App\adc;F:\嵌入式Linux学习资料\RT-Node\App\env;F:\嵌入式Linux学习资料\RT-Node\Driver\bme280;F:\嵌入式Linux学习资料\RT-Node\App\display;F:\嵌入式Linux学习资料\RT-Node\App\health
  memory RVCT4: ROM 0x8000000 size 0x7F800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    F:/嵌入式Linux学习资料/RT-Node/Core/Src/: main.c i2c_msp.c interrupts.c freertos_static.c rtos_hooks.c
  group Actuator
    F:/嵌入式Linux学习资料/RT-Node/App/actuator/src/: actuator.c
  group Startup
    F:/嵌入式Linux学习资料/RT-Node/Startup/: startup_stm32f103xe.s
  group CMSIS
    F:/嵌入式Linux学习资料/RT-Node/Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group HAL
    F:/嵌入式Linux学习资料/RT-Node/Driver/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_iwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_can.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c
  group tests
    F:/嵌入式Linux学习资料/RT-Node/App/p1a_test/: p1a_test.c
  group Control
    F:/嵌入式Linux学习资料/RT-Node/App/control/: control.c control_policy.c local_follow.c
    F:/嵌入式Linux学习资料/RT-Node/App/p1b_test/: p1b_test.c
  group FreeRTOS
    F:/嵌入式Linux学习资料/RT-Node/Middlewares/FreeRTOS/: tasks.c list.c queue.c
    F:/嵌入式Linux学习资料/RT-Node/Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Health
    F:/嵌入式Linux学习资料/RT-Node/App/health/: health_app.c health_runtime.c
  group UART
    F:/嵌入式Linux学习资料/RT-Node/App/uart/: uart_app.c
  group ADC
    F:/嵌入式Linux学习资料/RT-Node/App/adc/: adc_app.c
  group Display
    F:/嵌入式Linux学习资料/RT-Node/App/display/: display_app.c
  group Environment
    F:/嵌入式Linux学习资料/RT-Node/App/env/: env_app.c
    F:/嵌入式Linux学习资料/RT-Node/Driver/bme280/: bme280.c
  group CAN
    F:/嵌入式Linux学习资料/RT-Node/App/can/: can_app.c
  group IMU
    F:/嵌入式Linux学习资料/RT-Node/Driver/imu/: icm20602.c icm20602_data.c
    F:/嵌入式Linux学习资料/RT-Node/App/imu/src/: imu_fusion.c imu.c
