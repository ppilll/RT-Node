# Keil uVision project RTnode.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x0007F800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTnode +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: P1A_ACTUATOR_TEST_ENABLE=0,P1A_AUTOTEST_ENABLE=0,P1A_AUTOTEST_CASE=1,P1B_AUTOTEST_ENABLE=0,STM32F103xE,USE_HAL_DRIVER,BME280_64BIT_ENABLE
  c include: ..\App\actuator\include;..\Core\Inc;..\Driver\CMSIS\Include;..\Driver\CMSIS\Device\ST\STM32F1xx\Include;..\Driver\STM32F1xx_HAL_Driver\Inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\App\imu\include;..\Driver\imu;..\App\can;..\App\uart;..\App\adc;..\App\env;..\Driver\bme280;..\App\display;..\App\health
  memory RVCT4: ROM 0x8000000 size 0x7F800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Core/Src/: main.c i2c_msp.c interrupts.c freertos_static.c rtos_hooks.c
  group Actuator
    ../App/actuator/src/: actuator.c
  group Startup
    ../Startup/: startup_stm32f103xe.s
  group CMSIS
    ../Driver/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group HAL
    ../Driver/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_iwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi.c stm32f1xx_hal_can.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc_ex.c
  group tests
    ../App/p1a_test/: p1a_test.c
  group Control
    ../App/control/: control.c control_policy.c local_follow.c
    ../App/p1b_test/: p1b_test.c
  group FreeRTOS
    ../Middlewares/FreeRTOS/: tasks.c list.c queue.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Health
    ../App/health/: health_app.c health_runtime.c
  group UART
    ../App/uart/: uart_app.c
  group ADC
    ../App/adc/: adc_app.c
  group Display
    ../App/display/: display_app.c
  group Environment
    ../App/env/: env_app.c
    ../Driver/bme280/: bme280.c
  group CAN
    ../App/can/: can_app.c
  group IMU
    ../Driver/imu/: icm20602.c icm20602_data.c
    ../App/imu/src/: imu_fusion.c imu.c
